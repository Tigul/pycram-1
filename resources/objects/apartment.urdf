Commit message: Milk and fridge works

File: resources/objects/apartment.urdf (robot description, URDF)
Before this commit: robot apartment, 124 links, 123 joints
Links:
- removed link fridge_level1
Joints:
- removed joint fridge_level1_joint
